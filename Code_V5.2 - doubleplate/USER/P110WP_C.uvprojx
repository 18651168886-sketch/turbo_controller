# Keil uVision project P110WP_C.uvprojx, settings and files
target 110WP-C-3 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ECU_110WP_C +hex
  AfterMake: fromelf --m32 --output=..\OBJ\ECU_110WP_C.srec ..\OBJ\ECU_110WP_C.axf
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\NRIST_lib;..\HARDWARE;..\SYSTEM;..\AutoCode;..\Fatfs;..\uCOS-II\Source;..\uCOS-II\Ports;..\uCOS-II
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\stm32f407.sct
  group USER
    ./: main.c stm32f4xx_it.c NRISTF4_Define.c NRISTF4_Control.c NRIST_Comm.c
    ../: readme.txt
  group CORE
    ../CORE/: startup_stm32f4xx.s system_stm32f4xx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/: bsp_rcc.c
  group HARDWARE
    ../HARDWARE/: bsp.c watchdog.c w25qxx.c fram.c sdio.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group NRISTLIB
    ../NRIST_lib/: NRIST_calculate.c NRISTF4_spi.c NRISTF4_flash.c NRISTF4_SPIflash.c NRISTF4_sdio.c
  group Fatfs
    ../Fatfs/: diskio.c ff.c
    ../Fatfs/option/: cc936.c syscall.c
  group ucosII
    ../uCOS-II/Ports/: os_cpu_c.c os_cpu_a.asm
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group AutoCode
    ../AutoCode/: EngineControl_GeneralModule.c EngineControl_Timmer.c rt_nonfinite.c rtGetInf.c rtGetNaN.c CYS_110WP_3_Control.c CYS_110WP_3_Control_data.c
